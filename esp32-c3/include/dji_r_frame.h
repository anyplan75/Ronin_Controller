#pragma once
#include <stdint.h>
#include <stddef.h>
#include <string.h>
#include <math.h>

// DJI R SDK 프레임입니다. 로닌 블루투스의 FFF5 에 그대로 씁니다. CAN 이 아닙니다.

inline uint16_t djiCrc16(const uint8_t* data, size_t len) {
  uint16_t crc = 0x3AA3;
  static const uint16_t table[256] = {
    0x0000, 0xC0C1, 0xC181, 0x0140, 0xC301, 0x03C0, 0x0280, 0xC241, 0xC601, 0x06C0, 0x0780, 0xC741, 0x0500, 0xC5C1, 0xC481, 0x0440, 0xCC01, 0x0CC0, 0x0D80, 0xCD41, 0x0F00, 0xCFC1, 0xCE81, 0x0E40, 0x0A00, 0xCAC1, 0xCB81, 0x0B40, 0xC901, 0x09C0, 0x0880, 0xC841, 0xD801, 0x18C0, 0x1980, 0xD941, 0x1B00, 0xDBC1, 0xDA81, 0x1A40, 0x1E00, 0xDEC1, 0xDF81, 0x1F40, 0xDD01, 0x1DC0, 0x1C80, 0xDC41, 0x1400, 0xD4C1, 0xD581, 0x1540, 0xD701, 0x17C0, 0x1680, 0xD641, 0xD201, 0x12C0, 0x1380, 0xD341, 0x1100, 0xD1C1, 0xD081, 0x1040, 0xF001, 0x30C0, 0x3180, 0xF141, 0x3300, 0xF3C1, 0xF281, 0x3240, 0x3600, 0xF6C1, 0xF781, 0x3740, 0xF501, 0x35C0, 0x3480, 0xF441, 0x3C00, 0xFCC1, 0xFD81, 0x3D40, 0xFF01, 0x3FC0, 0x3E80, 0xFE41, 0xFA01, 0x3AC0, 0x3B80, 0xFB41, 0x3900, 0xF9C1, 0xF881, 0x3840, 0x2800, 0xE8C1, 0xE981, 0x2940, 0xEB01, 0x2BC0, 0x2A80, 0xEA41, 0xEE01, 0x2EC0, 0x2F80, 0xEF41, 0x2D00, 0xEDC1, 0xEC81, 0x2C40, 0xE401, 0x24C0, 0x2580, 0xE541, 0x2700, 0xE7C1, 0xE681, 0x2640, 0x2200, 0xE2C1, 0xE381, 0x2340, 0xE101, 0x21C0, 0x2080, 0xE041, 0xA001, 0x60C0, 0x6180, 0xA141, 0x6300, 0xA3C1, 0xA281, 0x6240, 0x6600, 0xA6C1, 0xA781, 0x6740, 0xA501, 0x65C0, 0x6480, 0xA441, 0x6C00, 0xACC1, 0xAD81, 0x6D40, 0xAF01, 0x6FC0, 0x6E80, 0xAE41, 0xAA01, 0x6AC0, 0x6B80, 0xAB41, 0x6900, 0xA9C1, 0xA881, 0x6840, 0x7800, 0xB8C1, 0xB981, 0x7940, 0xBB01, 0x7BC0, 0x7A80, 0xBA41, 0xBE01, 0x7EC0, 0x7F80, 0xBF41, 0x7D00, 0xBDC1, 0xBC81, 0x7C40, 0xB401, 0x74C0, 0x7580, 0xB541, 0x7700, 0xB7C1, 0xB681, 0x7640, 0x7200, 0xB2C1, 0xB381, 0x7340, 0xB101, 0x71C0, 0x7080, 0xB041, 0x5000, 0x90C1, 0x9181, 0x5140, 0x9301, 0x53C0, 0x5280, 0x9241, 0x9601, 0x56C0, 0x5780, 0x9741, 0x5500, 0x95C1, 0x9481, 0x5440, 0x9C01, 0x5CC0, 0x5D80, 0x9D41, 0x5F00, 0x9FC1, 0x9E81, 0x5E40, 0x5A00, 0x9AC1, 0x9B81, 0x5B40, 0x9901, 0x59C0, 0x5880, 0x9841, 0x8801, 0x48C0, 0x4980, 0x8941, 0x4B00, 0x8BC1, 0x8A81, 0x4A40, 0x4E00, 0x8EC1, 0x8F81, 0x4F40, 0x8D01, 0x4DC0, 0x4C80, 0x8C41, 0x4400, 0x84C1, 0x8581, 0x4540, 0x8701, 0x47C0, 0x4680, 0x8641, 0x8201, 0x42C0, 0x4380, 0x8341, 0x4100, 0x81C1, 0x8081, 0x4040
  };
  for (size_t i = 0; i < len; i++) {
    crc = (uint16_t)((crc >> 8) ^ table[(crc ^ data[i]) & 0xFF]);
  }
  return crc;
}

inline uint32_t djiCrc32(const uint8_t* data, size_t len) {
  uint32_t crc = 0x3AA3;
  static const uint32_t table[256] = {
    0x00000000, 0x77073096, 0xEE0E612C, 0x990951BA, 0x076DC419, 0x706AF48F, 0xE963A535, 0x9E6495A3, 0x0EDB8832, 0x79DCB8A4, 0xE0D5E91E, 0x97D2D988, 0x09B64C2B, 0x7EB17CBD, 0xE7B82D07, 0x90BF1D91, 0x1DB71064, 0x6AB020F2, 0xF3B97148, 0x84BE41DE, 0x1ADAD47D, 0x6DDDE4EB, 0xF4D4B551, 0x83D385C7, 0x136C9856, 0x646BA8C0, 0xFD62F97A, 0x8A65C9EC, 0x14015C4F, 0x63066CD9, 0xFA0F3D63, 0x8D080DF5, 0x3B6E20C8, 0x4C69105E, 0xD56041E4, 0xA2677172, 0x3C03E4D1, 0x4B04D447, 0xD20D85FD, 0xA50AB56B, 0x35B5A8FA, 0x42B2986C, 0xDBBBC9D6, 0xACBCF940, 0x32D86CE3, 0x45DF5C75, 0xDCD60DCF, 0xABD13D59, 0x26D930AC, 0x51DE003A, 0xC8D75180, 0xBFD06116, 0x21B4F4B5, 0x56B3C423, 0xCFBA9599, 0xB8BDA50F, 0x2802B89E, 0x5F058808, 0xC60CD9B2, 0xB10BE924, 0x2F6F7C87, 0x58684C11, 0xC1611DAB, 0xB6662D3D, 0x76DC4190, 0x01DB7106, 0x98D220BC, 0xEFD5102A, 0x71B18589, 0x06B6B51F, 0x9FBFE4A5, 0xE8B8D433, 0x7807C9A2, 0x0F00F934, 0x9609A88E, 0xE10E9818, 0x7F6A0DBB, 0x086D3D2D, 0x91646C97, 0xE6635C01, 0x6B6B51F4, 0x1C6C6162, 0x856530D8, 0xF262004E, 0x6C0695ED, 0x1B01A57B, 0x8208F4C1, 0xF50FC457, 0x65B0D9C6, 0x12B7E950, 0x8BBEB8EA, 0xFCB9887C, 0x62DD1DDF, 0x15DA2D49, 0x8CD37CF3, 0xFBD44C65, 0x4DB26158, 0x3AB551CE, 0xA3BC0074, 0xD4BB30E2, 0x4ADFA541, 0x3DD895D7, 0xA4D1C46D, 0xD3D6F4FB, 0x4369E96A, 0x346ED9FC, 0xAD678846, 0xDA60B8D0, 0x44042D73, 0x33031DE5, 0xAA0A4C5F, 0xDD0D7CC9, 0x5005713C, 0x270241AA, 0xBE0B1010, 0xC90C2086, 0x5768B525, 0x206F85B3, 0xB966D409, 0xCE61E49F, 0x5EDEF90E, 0x29D9C998, 0xB0D09822, 0xC7D7A8B4, 0x59B33D17, 0x2EB40D81, 0xB7BD5C3B, 0xC0BA6CAD, 0xEDB88320, 0x9ABFB3B6, 0x03B6E20C, 0x74B1D29A, 0xEAD54739, 0x9DD277AF, 0x04DB2615, 0x73DC1683, 0xE3630B12, 0x94643B84, 0x0D6D6A3E, 0x7A6A5AA8, 0xE40ECF0B, 0x9309FF9D, 0x0A00AE27, 0x7D079EB1, 0xF00F9344, 0x8708A3D2, 0x1E01F268, 0x6906C2FE, 0xF762575D, 0x806567CB, 0x196C3671, 0x6E6B06E7, 0xFED41B76, 0x89D32BE0, 0x10DA7A5A, 0x67DD4ACC, 0xF9B9DF6F, 0x8EBEEFF9, 0x17B7BE43, 0x60B08ED5, 0xD6D6A3E8, 0xA1D1937E, 0x38D8C2C4, 0x4FDFF252, 0xD1BB67F1, 0xA6BC5767, 0x3FB506DD, 0x48B2364B, 0xD80D2BDA, 0xAF0A1B4C, 0x36034AF6, 0x41047A60, 0xDF60EFC3, 0xA867DF55, 0x316E8EEF, 0x4669BE79, 0xCB61B38C, 0xBC66831A, 0x256FD2A0, 0x5268E236, 0xCC0C7795, 0xBB0B4703, 0x220216B9, 0x5505262F, 0xC5BA3BBE, 0xB2BD0B28, 0x2BB45A92, 0x5CB36A04, 0xC2D7FFA7, 0xB5D0CF31, 0x2CD99E8B, 0x5BDEAE1D, 0x9B64C2B0, 0xEC63F226, 0x756AA39C, 0x026D930A, 0x9C0906A9, 0xEB0E363F, 0x72076785, 0x05005713, 0x95BF4A82, 0xE2B87A14, 0x7BB12BAE, 0x0CB61B38, 0x92D28E9B, 0xE5D5BE0D, 0x7CDCEFB7, 0x0BDBDF21, 0x86D3D2D4, 0xF1D4E242, 0x68DDB3F8, 0x1FDA836E, 0x81BE16CD, 0xF6B9265B, 0x6FB077E1, 0x18B74777, 0x88085AE6, 0xFF0F6A70, 0x66063BCA, 0x11010B5C, 0x8F659EFF, 0xF862AE69, 0x616BFFD3, 0x166CCF45, 0xA00AE278, 0xD70DD2EE, 0x4E048354, 0x3903B3C2, 0xA7672661, 0xD06016F7, 0x4969474D, 0x3E6E77DB, 0xAED16A4A, 0xD9D65ADC, 0x40DF0B66, 0x37D83BF0, 0xA9BCAE53, 0xDEBB9EC5, 0x47B2CF7F, 0x30B5FFE9, 0xBDBDF21C, 0xCABAC28A, 0x53B39330, 0x24B4A3A6, 0xBAD03605, 0xCDD70693, 0x54DE5729, 0x23D967BF, 0xB3667A2E, 0xC4614AB8, 0x5D681B02, 0x2A6F2B94, 0xB40BBE37, 0xC30C8EA1, 0x5A05DF1B, 0x2D02EF8D
  };
  for (size_t i = 0; i < len; i++) {
    crc = (crc >> 8) ^ table[(crc ^ data[i]) & 0xFF];
  }
  return crc;
}

inline size_t djiBuild(uint8_t* out, size_t cap, uint8_t cmdSet, uint8_t cmdId, uint8_t cmdType, uint16_t seq, const uint8_t* payload, size_t payloadLen) {
  size_t total = 18 + payloadLen;
  if (out == nullptr || total > cap || total > 255) return 0;
  memset(out, 0, total);
  out[0] = 0xAA;
  out[1] = (uint8_t)total;
  out[3] = cmdType;
  out[8] = (uint8_t)(seq & 0xFF);
  out[9] = (uint8_t)(seq >> 8);
  uint16_t header = djiCrc16(out, 10);
  out[10] = (uint8_t)(header & 0xFF);
  out[11] = (uint8_t)(header >> 8);
  out[12] = cmdSet;
  out[13] = cmdId;
  for (size_t i = 0; i < payloadLen; i++) out[14 + i] = payload[i];
  uint32_t tail = djiCrc32(out, total - 4);
  out[total - 4] = (uint8_t)tail;
  out[total - 3] = (uint8_t)(tail >> 8);
  out[total - 2] = (uint8_t)(tail >> 16);
  out[total - 1] = (uint8_t)(tail >> 24);
  return total;
}

inline int16_t djiDecideg(float deg, int16_t minV, int16_t maxV) {
  int32_t value = (int32_t)lroundf(deg * 10.0f);
  if (value < minV) value = minV;
  if (value > maxV) value = maxV;
  return (int16_t)value;
}

inline size_t djiMoveTo(uint8_t* out, size_t cap, uint16_t seq, float yawDeg, float pitchDeg, float timeSec, bool absolute) {
  uint8_t payload[8];
  int16_t yaw = djiDecideg(yawDeg, -1800, 1800);
  int16_t roll = 0;
  int16_t pitch = djiDecideg(pitchDeg, -560, 1460);
  payload[0] = (uint8_t)(yaw & 0xFF);
  payload[1] = (uint8_t)(yaw >> 8);
  payload[2] = (uint8_t)(roll & 0xFF);
  payload[3] = (uint8_t)(roll >> 8);
  payload[4] = (uint8_t)(pitch & 0xFF);
  payload[5] = (uint8_t)(pitch >> 8);
  // bit0=절대, bit1~3=축 무효(0=유효). 0x01 = 절대·3축 유효.
  payload[6] = absolute ? 0x01 : 0x00;
  if (timeSec < 0.1f) timeSec = 0.1f;
  if (timeSec > 25.0f) timeSec = 25.0f;
  payload[7] = (uint8_t)lroundf(timeSec * 10.0f);
  return djiBuild(out, cap, 0x0E, 0x00, 0x03, seq, payload, sizeof(payload));
}

inline size_t djiSpeed(uint8_t* out, size_t cap, uint16_t seq, float yawDps, float pitchDps) {
  uint8_t payload[7];
  int16_t yaw = djiDecideg(yawDps, -3600, 3600);
  int16_t roll = 0;
  int16_t pitch = djiDecideg(pitchDps, -3600, 3600);
  payload[0] = (uint8_t)(yaw & 0xFF);
  payload[1] = (uint8_t)(yaw >> 8);
  payload[2] = (uint8_t)(roll & 0xFF);
  payload[3] = (uint8_t)(roll >> 8);
  payload[4] = (uint8_t)(pitch & 0xFF);
  payload[5] = (uint8_t)(pitch >> 8);
  payload[6] = 0x88;
  return djiBuild(out, cap, 0x0E, 0x01, 0x03, seq, payload, sizeof(payload));
}

inline size_t djiGetAttitude(uint8_t* out, size_t cap, uint16_t seq) {
  uint8_t payload[1] = {0x01};
  return djiBuild(out, cap, 0x0E, 0x02, 0x03, seq, payload, sizeof(payload));
}

// RS2 앞 다이얼(줌/포커스 모터). +speed=줌 인, -speed=줌 아웃, 0=멈춤. 범위 ±2048.
inline size_t djiDial(uint8_t* out, size_t cap, uint16_t seq, int16_t speed) {
  if (speed < -2048) speed = -2048;
  if (speed > 2048) speed = 2048;
  uint8_t payload[3];
  payload[0] = 0x02;
  payload[1] = (uint8_t)(speed & 0xFF);
  payload[2] = (uint8_t)(speed >> 8);
  return djiBuild(out, cap, 0x0E, 0x0A, 0x03, seq, payload, sizeof(payload));
}

// 액션캠·로닌 BLE 공통 연결 요청(0x00/0x19). verifyMode 0=저장 페어 시도.
inline size_t djiAuthConnect(uint8_t* out, size_t cap, uint16_t seq, uint32_t senderId, const uint8_t mac[6],
                             uint8_t verifyMode, uint16_t verify) {
  uint8_t payload[36];
  memset(payload, 0, sizeof(payload));
  payload[0] = (uint8_t)(senderId);
  payload[1] = (uint8_t)(senderId >> 8);
  payload[2] = (uint8_t)(senderId >> 16);
  payload[3] = (uint8_t)(senderId >> 24);
  payload[4] = 6;
  if (mac != nullptr) {
    for (int i = 0; i < 6; i++) payload[5 + i] = mac[i];
  }
  payload[25] = verifyMode;
  payload[26] = (uint8_t)(verify & 0xFF);
  payload[27] = (uint8_t)(verify >> 8);
  return djiBuild(out, cap, 0x00, 0x19, 0x02, seq, payload, sizeof(payload));
}

inline bool djiParseHeader(const uint8_t* raw, size_t len, uint8_t* cmdSet, uint8_t* cmdId, uint8_t* cmdType,
                           const uint8_t** payload, size_t* payloadLen) {
  if (raw == nullptr || len < 16 || raw[0] != 0xAA) return false;
  size_t total = (size_t)raw[1] | (((size_t)(raw[2] & 0x03)) << 8);
  if (total != len || total < 16) return false;
  if (cmdType) *cmdType = raw[3];
  if (cmdSet) *cmdSet = raw[12];
  if (cmdId) *cmdId = raw[13];
  if (payload) *payload = raw + 14;
  if (payloadLen) *payloadLen = total - 18;
  return true;
}
